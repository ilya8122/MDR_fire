# Keil uVision project fire_milandr.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE93 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fire_milandr
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;.\src;.\Config;.\libs\w25q
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\fire_milandr.sct
  group APP
    ./src/: main.c MDR32F9Qx_it.c uart_app.c timer.c terminal.c CmdLineTerminal.c command.c tools.c testMelody.c led.c player.c adc.c spi.c channel.c sensors.c detect.c
    ./inc/: dictionary.h fire_sensor_module.h
    ./: fire_sensor_module.c
  group config
    ./Config/: MDR32F9Qx_board.h MDR32F9Qx_config.h
  group libs
    ./libs/w25q/: w25qxx.c w25qxx.h w25qxxConf.h
software components: Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.5, Drivers:ADC 1.5, Drivers:CAN 1.5, Drivers:DAC 1.5, Drivers:DMA 1.5, Drivers:EEPROM 1.5, Drivers:IWDG 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
